** sch_path: xschem/ARRAY/n1_4.sch
**.subckt n1_4 D G S B
*.iopin D
*.iopin G
*.iopin S
*.iopin B
xd D G X B n1_2
xs X G S B n1_2
**.ends
.end
