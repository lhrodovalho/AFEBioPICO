** sch_path: xschem/ARRAY/n2_2.sch
**.subckt n2_2 D G S B
*.iopin D
*.iopin G
*.iopin S
*.iopin B
xr D G S B n1_2
xl D G S B n1_2
**.ends
.end
