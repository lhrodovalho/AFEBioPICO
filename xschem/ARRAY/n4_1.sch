** sch_path: xschem/ARRAY/n4_1.sch
**.subckt n4_1 D G S B
*.iopin D
*.iopin G
*.iopin S
*.iopin B
xr D G S B n2_1
xl D G S B n2_1
**.ends
.end
