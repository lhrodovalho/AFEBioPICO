** sch_path: xschem/ARRAY/p1_8.sch
**.subckt p1_8 D G S B
*.iopin D
*.iopin G
*.iopin S
*.iopin B
xs X G S B p1_4
xd D G X B p1_4
**.ends
.end
