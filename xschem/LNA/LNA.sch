v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {LNA/LNA_OPAMP.sym} 0 0 0 0 {name=X1}
