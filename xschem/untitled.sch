v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {FILTER/ideal_FILTER.sym} 2510 -1410 0 0 {name=X1}
